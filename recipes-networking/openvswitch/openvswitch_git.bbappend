RDEPENDS_${PN}_remove += "python3 python3-twisted python3-six"
