RDEPENDS_${PN}_remove += "python python-twisted python-six"
